# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx USE_STDPERIPH_DRIVER EMPL_TARGET_STM32F4 ARM_MATH_CM4
  c misc: --C99
  c include: ..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\Libraries\cmsis\Include;..\Libraries\cmsis;..\IMU;..\IMU\eMPL;..\RM_lib;..\FATFS\exfuns;..\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: main.c system.c my_math.c stm32f4xx_it.c
  group BSP
    ../BSP/: sd.c adc.c dma.c nvic.c usart.c gpio.c timer.c malloc.c yixiuge.c sdio_sdcard.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group STM32_StdPeriph
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_dbgmcu.c stm32f4xx_sdio.c
    ../Libraries/cmsis/: system_stm32f4xx.c
    ../Libraries/startup/: startup_stm32f429_439xx.s
